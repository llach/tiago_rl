Commit message: cylinder uses real-life parameters, wait period in main loop

File: tiago_rl/assets/objects/cylinder.urdf (robot description, URDF)
Before this commit: robot cylinder, 1 links, 0 joints
Links:
- link cylinderLink: mass 0.5 -> 0.421
